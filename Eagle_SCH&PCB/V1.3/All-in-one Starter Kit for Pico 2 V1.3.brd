# Repository Elecrow-RD/All-in-one-Starter-Kit-for-Pico-2

File readme.md:

### 1, Product picture

https://www.elecrow.com/all-in-one-starter-kit-for-pico-2-with-common-board-design-17-sensors-and-21-lessons.html

### 2, Product version number

|      | Hardware | Software | Remark |
| ---- | -------- | -------- | ------ |
| 1    | V1.0     | V1.0     | old |
| 1    | V1.1     | V1.1     | old |
| 1    | V1.2     | V1.1     | old |
| 1    | V1.3     | V1.1     | latest |

#### v1.1 Update:

Replaced gyroscope sensor chip, removed MPU6050 circuit, and replaced it with LSM6DS3 circuit. Rearranged positions of red, green, and yellow LED beads.

#### v1.3 Update:
Added a switching power supply for the servo.

### 3, product information

- Main Processor IC: RP2350A
- Interface: Type-C Interface
- Size: 195*170*46(mm)
- Material:PP(Non-toxic)
- Weight: 340g

|                         | [ All-in-one Starter Kit for Pico 2](https://www.elecrow.com/all-in-one-starter-kit-for-pico-2-with-common-board-design-17-sensors-and-21-lessons.html) |
| ----------------------- | ------------------------------------------------------------ |
| Main Processor          | Pico 2 RP2350                                                |
| Number of Sensors       | 17 sensors                                                   |
| Sensor Board Design     | Integrated sensor board, no soldering or complex wiring required |
| Screen                  | 2.4-inch TFT full-color touch screen                         |
| Ambient Lights          | 20 full-color ambient lights, switchable via touch screen    |
| Built-in Mini Games     | Yes                                                          |
| Expansion Interfaces    | None                                                         |
| Programming Environment | Based on Arduino software                                    |
| Number of Tutorials     | 21 creative tutorials                                        |
| Dimension               | 195×170×46 mm                                                |
| Target Audience         | Students, teachers, hardware enthusiasts                     |
| Application Scenarios   | Ideal for learning Pico 2 programming basics                 |

### 4,Quick Start

##### Arduino IDE starts

1.Download the library files used by this product to the 'libraries' folder.

C:\Users\Documents\Arduino\libraries\

2.Open the Arduino IDE

3.Open the code configuration environment and burn it

### 5,Folder structure.

|--3D file： Contains 3D model files (.stp) for the hardware. These files can be used for visualization, enclosure design, or integration into CAD software.

|--Datasheet: Includes datasheets for components used in the project, providing detailed specifications, electrical characteristics, and pin configurations.

|--Eagle_SCH&PCB: Contains **Eagle CAD** schematic (`.sch`) and PCB layout (`.brd`) files. These are used for circuit design and PCB manufacturing.

|--example: Provides example code and projects to demonstrate how to use the hardware and libraries. These examples help users get started quickly.

|--factory_firmware: Stores pre-compiled factory firmware that can be directly flashed onto the device. This ensures the device runs the default functionality.

|--factory_sourcecode: Contains the source code for the factory firmware, allowing users to modify and rebuild the firmware as needed.

### 6,Pin definition

## EAGLE design Eagle_SCH&PCB/V1.3/All-in-one Starter Kit for Pico 2 V1.3.brd

Parts:
BOOT: TS3425BA; SMD_KEY4.2*3.*.2.5
BUZ1: BUZZER_1295; BUZZER-D12MM-DIP2
C1, C2: 15pF/16V; C0603
C3, C6, C18, C19, C32, C33, C35, C36, C37, C38, C39, C41, C46, C52, C57, C64, C65, C68, C409, C411: 100nF; C0603
C4, C17, C25, C26: 4.7uF/16V; C0603
C5: 104; C0805
C7, C10, C11, C12, C13, C14, C15, C16, C20, C21, C22, C23, C24, C50: 100nF/16V; C0603
C8, C90, C183, C213, C214: 4.7uF; C0603
C9: 22nF; C0603
C27, C28, C30, C44, C51, C66, C413, C414: 22uF; C0805
C29: 10UF; C0805
C31: 100UF; SANYO-OSCON_SMD_C6
C34, C45, C49: 1uF; C0603
C40: 22uF; C0603
C42, C43: 2.2uF/16V; C0603
C47, C48: 100nF/0603; C0603
C55, C58, C59: 22UF/16V; C0603
C56, C60: 100NF; C0603
C67: 27pF; C0603
C212: 12pF(1-50P); C0603
C412: 10nF; C0603
D001: B5819WT; D_SOD523
D002, D004: 1N4148; D_SOD123
D3: NC; D_SOD123FL
D005: GREEN; LED-8MM
D006: Yellow; LED-8MM
D007: SS54/SMA; DIODE_DO-214AC
D10: B5819W; SOD-123_MINI-SMA
D11: RED; LED-8MM
D012, D019, D021, D022, D023, D024, D025, D026, D027, D028, D029, D030, D031, D032, D033, D183, D184, D185, D186, D187: WS2812B; LED_RGB_WS2812_3535
D143: NC/Green; LED_0603_SMT
FB1: NC; L0805
FB2, FB4: R_120/100MHZ_3A; L0805
FB3: R_600/100MHZ_0.5A; L0603
FPC1: P024C128-CTPFPC-P0.5MM-16P-SMD; FPC-P0.5MM-16P-SMD
FUSE: 500MA; R0805
J1: A_XBJ_CONNECTOR_TWIG-4P-2.0-SMD-FEMALE-REINFORCE9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; A_XBJ_CONNECTOR_4P-SMD-2.0-90D
J2: MQ-SOCKET; MQ2
J3: SOUND; TEMPLATE_2P-D8.9MM
J4, J5, J6, J7: TP-SMDTP-SMD-2X4MM; TP-SMD-2X4MM
J8: PH2.0-4P-WOTIE; PH2.0-4P
J14: CROWPI_POW_ULTRA
J15: CON-2.54MM-3P; CON-PZ-2.54MM-1*3P-WT
J110: switch_6pin; SWITCH_6PIN_2P
J123: 3.5MM3P; 3.5MM*3P
J313: MOTOR_1CN; MOTOR_1CM
K1, K2, K3, K4: BUTTON_2P
L1: 3.3uH; SMD,1.6X2MM
L2: CD32_950MA; CD32
L3: 10UH; MS42
L11: 0R; 201209
L401: 33UH; L773
LED1: RED; DISCRETE_LED-0603
P1, P3, P4, P5, P6, P7, P8, P9, P10, P11, P12, P13, P14, P15, P16, P17, P18, P19, P20, P21, P22, P23, P24, P30, P53, P55, P61, P69, P70: PADPAD-1.0MM; PAD-1.0MM
P2: R-POTENTIOMETER; 3P-SQUA-45.6X10X5.8H
P101: KEY; 1P-D450
Q1, Q2, Q3, Q6, Q103, Q104, Q115: S9013; SOT23@1
Q5: SS8050W-SOT323; MOS_SOT323
Q7: BSS138; SOT23
Q405: 2N7002; SOT23
R1, R4, R9, R12, R13, R14, R21, R58, R63, R107, R115, R116, R191, R273, R280, R286, R288, R301, R302: 10K; R0603
R2, R6, R17, R22, R41, R59, R61, R274, R287, R639: 1K; R0603
R3: 4.7K 1%; R0603
R5, R47: 10k; R0603
R7, R23: 470R; R0603
R8: 1k; R0603
R10, R11: 27.4R; R0603
R15, R34, R118, R329: NC; R0603
R16: 33R; R0603
R18, R19, R24, R36, R84, R85, R423: 4.7K; R0603
R20: 100R; R0603
R25, R26, R27, R28, R29, R54, R82, R83: 0R; R0603
R30: 95.3K; R0603
R32: 13K; R0603
R35: 5.1R; R0603
R40: 10R; R0603
R42: 47K; R0603
R43, R44, R45, R46, R422: 4.7k; R0603
R56: 51K; R0603
R57: 510K; R0603
R62: 10K; 3P-SMD-SQUA-3.6X3.3
R76: 30.9K 1%; R0603
R117: 14k; R0603
R190: 3.3k; R0603
R276, R283, R303: 22R; R0603
R282, R284, R299: 2K; R0603
R411: 30K/1%; R0603
R412: 18K/1%; R0603
R622: 200K; R0603
R652: 2.7K; R0603
R653: 3.74K; R0603
R654: 5.6K; R0603
R655: 8.2K; R0603
RELAY1: RELAY-SRD; REY5-6-19.1X15.5X15.3MM
RESET: TS3425BA; SMD_KEY4.2*3.*.2.5
U1: RP2350A; QFN-60_7X7MM
U2: APS6404L; SOP-8L
U3: W25Q64JVXGIQ; W25QXX-XSON-8-EP(4X4)
U5: DHT20; CROWTAIL-DHT20-V1.0-20211013_DHT20
U6: HAL248; SOT-23W
U7: BH1750; BH1750-WSOF-6
U8: MT3608; DBV_R-PDSO-G6
U10: SN74LVC1G125; SOT23-5
U11: LM393; SOP8@1
U12: LSM6DS3TR-C; LGA-14L
U30: MT2492; MT2492-SOT23-6
U34: LPW5206AB5F; IC_SOT23-5
U41: PW1503; SOT23-5
U123: TTP223; SOT23-6L
U309: IR-3PSIP3; VS1838B-SIP3
U401: TD1509
X1: X322512MSB4SI; A_XBJ_SMD3225

Connections:
+1V1: C4.1, C15.1, C24.1, C26.2, L1.P$1 (1), U1.P$6 (DVDD2), U1.P$23 (DVDD1), U1.P$39 (DVDD0), U1.P$50 (VREG_FB)
BOOT: BOOT.P$1 (1), R2.2
COM: J123.2, RELAY1.2
CORE_RESET: C14.2, D001.-, R5.1, RESET.P$2 (2), U1.P$26 (RUN)
DC_OUT1: D007.C, L401.1, U401.P$2 (2_VOUT)
FB1: C412.1, R411.1, R412.2, U401.P$3 (3_FB)
GND: BOOT.P$4 (4), C1.1, C2.2, C3.1, C4.2, C5.1, C6.1, C7.1, C8.2, C10.2, C11.2, C12.2, C13.2, C14.1, C15.2, C16.2, C17.2, C18.1, C19.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.1, C26.1, C27.2, C28.2, C29.2, C30.2, C31.-, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.2, C45.1, C46.2, C47.1, C48.1, C49.1, C50.1, C51.2, C52.1, C55.1, C56.1, C57.2, C58.1, C59.1, C60.1, C64.1, C66.2, C67.1, C68.1, C90.2, C183.2, C212.1, C213.1, C214.1, C409.1, C411.1, C413.2, C414.2, D007.A, D012.3 (3_GND), D019.3 (3_GND), D021.3 (3_GND), D022.3 (3_GND), D023.3 (3_GND), D024.3 (3_GND), D025.3 (3_GND), D026.3 (3_GND), D027.3 (3_GND), D028.3 (3_GND), D029.3 (3_GND), D030.3 (3_GND), D031.3 (3_GND), D032.3 (3_GND), D033.3 (3_GND), D183.3 (3_GND), D184.3 (3_GND), D185.3 (3_GND), D186.3 (3_GND), D187.3 (3_GND), FPC1.P$1 (GND), FPC1.P$16 (GND), FPC1.P$17 (G2), FPC1.P$18 (G1), J1.4, J1.SS1, J1.SS2, J3.2 (-), J7.1, J8.4, J8.5 (SS1), J8.6 (SS2), J14.P$1 (1_GND), J15.3 (S), K1.P$1, K2.P$1, K3.P$1, K4.P$1, P2.1, P4.P$1, P9.P$1, P11.P$1, P24.P$1, Q1.2 (E), Q2.2 (E), Q3.2 (E), Q5.2 (E), Q6.2 (E), Q103.2 (E), Q104.2 (E), Q115.2 (E), R3.1, R4.1, R13.1, R15.1, R21.1, R32.2, R35.1, R36.2, R42.2, R56.2, R62.1, R82.1, R83.1, R115.2, R117.2, R190.2, R273.1, R280.1, R286.2, R288.2, R302.1, R412.1, R622.2, RESET.P$3 (3), U1.P$47 (VREG_PGND), U1.P$61 (GND), U2.P$4 (VSS), U3.4 (GND), U3.EP (GND), U5.3 (GND), U6.3 (GND), U7.3 (GND\), U8.2 (GND), U10.1 (OE), U10.3 (GND), U11.4 (4_GND), U12.6 (GND), U12.7 (GND), U30.2 (GND), U34.2 (2_GND), U41.2 (GND), U123.2 (GND), U309.2, U401.P$4 (4_EN), U401.P$5 (5_GND), U401.P$6 (6_GND), U401.P$7 (7_GND), U401.P$8 (8_GND), X1.2 (GND), X1.4 (GND)
GP0_LED_BK: R41.2, U1.P$2 (GPIO0)
GP1_PSRAM_CS: R14.1, U1.P$3 (GPIO1), U2.P$1 (/CE)
GP2/I2C1_SDA: R18.2, R26.2, U5.2 (SDA), U7.4 (SDA), U12.14 (SDA)
GP3/I2C1_SCL: R19.2, R27.2, U5.4 (SCL), U7.6 (SCL), U12.13 (SCL)
GP4/I2C0_SDA: FPC1.P$4 (YD/CTP_SDA), P16.P$1, R28.2, R45.1
GP5/I2C0_SCL: FPC1.P$3 (XR/CTP_SCL), P15.P$1, R29.2, R46.1
GP6_SPI0_CLK_TFT: FPC1.P$13 (SCL), P21.P$1, R43.1, U1.P$9 (GPIO6)
GP7_SPI0_MOSI_TFT: FPC1.P$14 (SDI), P22.P$1, R44.1, U1.P$10 (GPIO7)
GP16_RS_TFT: FPC1.P$7 (RS), P19.P$1, U1.P$27 (GPIO16)
GP17_SPI0_CS_TFT: FPC1.P$12 (CS), P20.P$1, U1.P$28 (GPIO17)
GP26_A0_GAS: J2.4 (B), J2.6 (B), R36.1, U1.P$40 (GPIO26_ADC0)
GP27_A1_KEY: P61.P$1, R639.2, R652.2, R653.2, R654.2, R655.2, U1.P$41 (GPIO27_ADC1)
GP28_A2_POT: C18.2, C40.2, P2.2 (3), U1.P$42 (GPIO28_ADC2)
GP29_A3_SOUND: P30.P$1, R61.1, U1.P$43 (GPIO29_ADC3), U11.1 (1_OUT1)
GPIO8_US_ECHO: R299.2, U1.P$12 (GPIO8)
GPIO9_US_TRIG: J14.P$3 (3_TRIG), U1.P$13 (GPIO9)
GPIO10_BUZZER: R284.1, U1.P$14 (GPIO10)
GPIO11_IR: R301.2, U1.P$15 (GPIO11), U309.3
GPIO12_RELAY: R274.2, U1.P$16 (GPIO12)
GPIO13_SERVO: P53.P$1, Q405.2 (S), R329.2, R422.1, U1.P$17 (GPIO13)
GPIO14_TOUCH: P55.P$1, R287.2, U1.P$18 (GPIO14)
GPIO15_VIB: R25.2, U1.P$19 (GPIO15)
GPIO18_LED_RED: R6.2, U1.P$29 (GPIO18)
GPIO19_LED_GREEN: R17.2, U1.P$31 (GPIO19)
GPIO20_LED_YELLOW: R22.2, U1.P$32 (GPIO20)
GPIO21_HALL: Q7.2 (S), R34.1, R107.1, U1.P$33 (GPIO21)
GPIO22_RGB: R54.1, U1.P$34 (GPIO22)
GPIO23_RGB_EN: R191.1, U1.P$35 (GPIO23)
GPIO24_TP_RST: FPC1.P$6 (YU/CTP_RST), P18.P$1, U1.P$36 (GPIO24)
GPIO25_TP_INT: FPC1.P$5 (XL/CTP_INT), P17.P$1, U1.P$37 (GPIO25)
IN1: C212.2, P101.1, U123.3 (IN)
IO0_VIB: R25.1, R280.2, R282.1
IO1_HALL: C34.2, Q7.3 (D), R34.2, R63.1, U6.2 (VOUT)
IO_LED_V: C30.1, C90.1, J110.2 (2_COM2), J110.5 (5_COM1), P70.P$1, R118.2, U34.1 (1_OUT)
IO_LED_VCC: C27.1, C28.1, C57.1, D012.1 (1_VDD), D019.1 (1_VDD), D021.1 (1_VDD), D022.1 (1_VDD), D023.1 (1_VDD), D024.1 (1_VDD), D025.1 (1_VDD), D026.1 (1_VDD), D027.1 (1_VDD), D028.1 (1_VDD), D029.1 (1_VDD), D030.1 (1_VDD), D031.1 (1_VDD), D032.1 (1_VDD), D033.1 (1_VDD), D183.1 (1_VDD), D184.1 (1_VDD), D185.1 (1_VDD), D186.1 (1_VDD), D187.1 (1_VDD), J110.1 (1_2B), U10.5 (VCC)
IO_RGB_OUT: D183.4 (4_DIN), U10.4 (Y)
IO_RGB_OUT1: D012.4 (4_DIN), D187.2 (2_DOUT)
IO_RGB_OUT2: D023.2 (2_DOUT), D024.4 (4_DIN)
IO_RGB_OUT3: D028.2 (2_DOUT), D029.4 (4_DIN)
LED_K: FPC1.P$9 (BL_K), P14.P$1, R40.2
unnamed: D012.2 (2_DOUT), D019.4 (4_DIN)
unnamed: C2.1, R8.2, X1.3 (XOUT)
unnamed: D019.2 (2_DOUT), D021.4 (4_DIN)
unnamed: R26.1, U1.P$4 (GPIO2)
unnamed: Q2.1 (B), R13.2, R17.1
unnamed: C17.1, R16.2, U1.P$46 (VREG_AVDD)
unnamed: D005.2 (C), Q2.3 (C)
unnamed: R27.1, U1.P$5 (GPIO3)
unnamed: C3.2, R9.2, U7.5 (DVI)
unnamed: D005.1 (A), R20.2
unnamed: Q3.1 (B), R21.2, R22.1
unnamed: L1.P$2 (2), U1.P$48 (VREG_LX)
unnamed: D021.2 (2_DOUT), D022.4 (4_DIN)
unnamed: Q1.1 (B), R4.2, R6.1
unnamed: D11.2 (C), Q1.3 (C)
unnamed: D11.1 (A), R7.2
unnamed: D006.2 (C), Q3.3 (C)
unnamed: D006.1 (A), R23.2
unnamed: LED1.+, R24.1
unnamed: D022.2 (2_DOUT), D023.4 (4_DIN)
unnamed: Q5.1 (B), R41.1, R42.1
unnamed: D024.2 (2_DOUT), D025.4 (4_DIN)
unnamed: J2.5 (H), R35.2
unnamed: D025.2 (2_DOUT), D026.4 (4_DIN)
unnamed: D026.2 (2_DOUT), D027.4 (4_DIN)
unnamed: D027.2 (2_DOUT), D028.4 (4_DIN)
unnamed: R82.2, U12.2 (SDX)
unnamed: D029.2 (2_DOUT), D030.4 (4_DIN)
unnamed: D030.2 (2_DOUT), D031.4 (4_DIN)
unnamed: D031.2 (2_DOUT), D032.4 (4_DIN)
unnamed: D032.2 (2_DOUT), D033.4 (4_DIN)
unnamed: C55.2, C56.2, D3.+, FUSE.2, L3.1, U8.4 (EN), U8.5 (IN)
unnamed: R28.1, U1.P$7 (GPIO4)
unnamed: R12.1, R15.2, U7.2 (ADDR)
unnamed: R30.2, R32.1, U8.3 (FB)
unnamed: D10.A, L3.2, U8.1 (SW)
unnamed: R190.1, U41.3 (IADJ)
unnamed: R29.1, U1.P$8 (GPIO5)
unnamed: J313.P$2, Q104.3 (C)
unnamed: Q5.3 (C), R40.1
unnamed: R83.2, U12.3 (SCX)
unnamed: R84.2, U12.12 (CS)
unnamed: R54.2, U10.2 (IN_A)
unnamed: C65.1, Q6.1 (B), R57.1
unnamed: C68.2, Q6.3 (C), R59.1, U11.2 (2_IN1-)
unnamed: R62.2 (3), U11.3 (3_IN1+)
unnamed: C65.2, C67.2, J3.1 (+), R56.1, R58.1
unnamed: R85.2, U12.1 (SDO)
unnamed: D143.2 (2_K), R622.1
unnamed: R115.1, R191.2, U30.4 (EN)
unnamed: K1.P$2, R652.1
unnamed: K2.P$2, R653.1
unnamed: K3.P$2, R654.1
unnamed: K4.P$2, R655.1
unnamed: C9.1, L2.1, U30.6 (SW)
unnamed: R3.2, R76.1, U30.3 (BF)
unnamed: C9.2, U30.1 (BS)
unnamed: R117.1, U34.3 (3_SET)
unnamed: R116.1, U34.4 (4_EN)
unnamed: Q115.1 (B), R273.2, R274.1
unnamed: C32.2, J313.P$1, R283.2
unnamed: R288.1, U123.4 (AHLB), U123.6 (TOG)
unnamed: Q104.1 (B), R282.2
unnamed: R286.1, R287.1, U123.1 (OUT)
unnamed: J14.P$2 (2_ECHO), R299.1
unnamed: Q103.1 (B), R284.2, R302.2
unnamed: BUZ1.2 (2-), D004.+, Q103.3 (C)
unnamed: BUZ1.1 (1+), D004.-, R303.2
unnamed: D183.2 (2_DOUT), D184.4 (4_DIN)
unnamed: D184.2 (2_DOUT), D185.4 (4_DIN)
unnamed: D185.2 (2_DOUT), D186.4 (4_DIN)
unnamed: D186.2 (2_DOUT), D187.4 (4_DIN)
NC: J123.1, RELAY1.4
NO: J123.3, RELAY1.5
QSPI_SCLK: U1.P$56 (QSPI_SCLK), U2.P$6 (SCLK), U3.6 (CLK)
QSPI_SD0: U1.P$57 (QSPI_SD0), U2.P$5 (SI/SIO0), U3.5 (DI(IO0))
QSPI_SD1: U1.P$59 (QSPI_SD1), U2.P$2 (SO/SIO1), U3.2 (DO(IO1))
QSPI_SD2: U1.P$58 (QSPI_SD2), U2.P$3 (SIO2), U3.3 (/WP(IO2))
QSPI_SD3: U1.P$55 (QSPI_SD3), U2.P$7 (SIO3), U3.7 (/HOLD(IO3))
QSPI_SS: R1.1, R2.1, U1.P$60 (QSPI_SS), U3.1 (/CS)
SERVO: J1.1, J15.1 (G), P12.P$1, Q405.3 (D), R329.1, R423.2
SWCLK: P5.P$1, U1.P$24 (SWCLK)
SWDIO: P6.P$1, U1.P$25 (SWD)
TFT_3V3: C47.2, C48.2, FB3.2, FPC1.P$2 (VCC), FPC1.P$10 (BL_A), FPC1.P$15 (VCC), P23.P$1, R43.2, R44.2, R45.2, R46.2, R47.2
TFT_RST: C49.2, D001.+, FPC1.P$11 (RESET), P13.P$1, R47.1
TYPE-C_N: J5.1, J8.3, R10.1
TYPE-C_P: J6.1, J8.2, R11.1
USB_D+: R11.2, U1.P$52 (USB_DP)
USB_D-: R10.2, U1.P$51 (USB_DM)
V+: R276.2, RELAY1.1
V-: D002.+, LED1.-, Q115.3 (C), RELAY1.3
VBUS: C5.2, C51.1, FB1.1, FUSE.1, J4.1, J8.1, U41.4 (EN), U41.5 (VIN)
VCC: C44.1, FB1.2, FB2.1, U41.1 (VOUT)
VCC3V3: C29.1, C409.2, C412.2, C414.1, D143.1 (1_A), FB4.1, L401.2, P1.P$1, P8.P$1, R411.2
VCC_3V3: C7.2, C10.1, C11.1, C12.1, C13.1, C16.1, C20.1, C21.1, C22.1, C23.1, C25.2, C37.2, C41.2, C42.2, C43.2, C45.2, C46.1, C50.2, C52.2, C64.2, C213.2, C214.2, FB3.1, FB4.2, J14.P$4 (4VCC), P2.3 (2), P3.P$1, Q7.1 (G), Q405.1 (G), R1.2, R5.2, R9.1, R12.2, R14.2, R16.1, R18.1, R19.1, R57.2, R58.2, R59.2, R61.2, R62.3 (2), R84.1, R85.1, R107.2, R301.1, R422.2, R639.1, U1.P$1 (IOVDD5), U1.P$11 (IOVDD4), U1.P$20 (IOVDD3), U1.P$30 (IOVDD2), U1.P$38 (IOVDD1), U1.P$44 (ADC_AVDD), U1.P$45 (IOVDD0), U1.P$49 (VREG_VIN), U1.P$53 (USB_OTP_VDD), U1.P$54 (QSPI_IOVDD), U2.P$8 (VDD), U3.8 (VCC), U5.1 (VCC), U7.1 (VCC), U11.8 (8_VCC), U12.5 (VDDIO), U12.8 (VDD), U123.5 (VCC), U309.1
VCC_5V: C19.1, C33.2, C35.2, C38.2, C39.2, C66.1, C411.2, C413.1, FB2.2, J2.2 (H), J2.3 (A), L11.1, P7.P$1, R7.1, R20.1, R23.1, R63.2, R283.1, R303.1, U6.1 (VCC), U30.5 (IN), U401.P$1 (1_VIN)
VCC_5V_SERVO: C6.2, C31.+, C58.2, C59.2, C60.2, D3.-, D10.C, J1.3, J15.2 (V), P10.P$1, R30.1, R423.1
VCC_IO_RGB: C8.1, C183.1, L2.2, P69.P$1, R76.2, R116.2, R118.1, U34.5 (5_VIN)
VCC_RELAY: C36.2, D002.-, L11.2, R24.2, R276.1
XIN: C1.2, U1.P$21 (XIN), X1.1 (XIN)
XOUT: R8.1, U1.P$22 (XOUT)

Notes on the sheet:
USB Adapter
RP2350A_MCU MIN System
RESET=0时，按下Boot下载模式
Temperature & Humidity(DHT20)
POWER 5V drop 3.3V
Boot=1,正常运行
NOR Flash
PORT:I2C1 ADDRESS:0X38
Buzeer
PORT:GPIO10_BUZZER
Ultrasonic Sensor
PORT:GPIO9&8
LIGHT SENSOR
PORT:I2C1 ADDR:0X5C
Linear Potentiometer
PORT:ADC_POT
Button
PORT:GP26_A0_PIR
Infrared Remote Sensor
PORT:GPIO11_IR
Relay
PORT:GPIO12_RELAY
Servo motor
PORT:GPIO13_SERVO
TTP223
Touch Sensor
PORT:GPIO14_TOUCH
Vibration sensor
PORT:GPIO15_VIB
HALL SENSOR
PORT:GGPIO21_HALL
GAS-MQ2
PORT:ADC_GAS
All-in-one Starter Kit for Pico 2 V1.1
TFT2.4 Inch LCD+TP
RGB_LED
SOUND_SENSOR
PORT:GP29_A3_SOUND
MPU-6050
PORT:I2C1 ADDR:0X68
